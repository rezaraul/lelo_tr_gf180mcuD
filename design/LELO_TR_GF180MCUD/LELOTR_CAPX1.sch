v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 0 0 0 {name=p0 lab=B}
C {devices/iopin.sym} 0 20 0 0 {name=p1 lab=A}
C {symbols/cap_mim_2f0fF.sym} 400 0 0 0 {name=C1
l=5.8e-6 w=5.8e-6 
model=cap_mim_2f0fF
m=1
spiceprefix=X
}
